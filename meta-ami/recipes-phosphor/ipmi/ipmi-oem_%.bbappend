FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
DEPENDS += "phosphor-logging sdbusplus"
SRC_URI_append += "file://0001-seladd-storagecommands-Renamed-log-directory.patch"
SRC_URI_append += "file://0002-To-read-digtal-sensor.patch"
SRC_URI_append += "file://0003-Initialising-sdr-from-json.patch"
SRC_URI_append += "file://0004-sensor-multiple-state-support.patch"
SRC_URI_append += "file://0005-commented-unused-command-ipmi-oem.patch"
SRC_URI_append += "file://0006-CPU-VR-set-threshhold.patch"
SRC_URI_append += "file://0007-clear-redfish-logs.patch"
SRC_URI_append += "file://0008-System-Airflow-sensor-unit.patch"
SRC_URI_append += "file://0009-change-cc-sensor-invalid.patch"
SRC_URI_append += "file://0010-reserve-sdr-privilage-change.patch"
SRC_URI_append += "file://0011-5th-byte-Sensor-Reading-command.patch"
SRC_URI_append += "file://0012-list-all-sellog-properly.patch"
SRC_URI_append += "file://0013-fixed_max_reading_error.patch"
SRC_URI_append += "file://0014-recordID-initialize-properly.patch"
SRC_URI_append += "file://0015-get-sensor-type-command.patch"
SRC_URI_append += "file://0016-get-sensor-reading-factors.patch"
SRC_URI_append += "file://0017-sensortype-fix.patch"
SRC_URI_append += "file://0018-get-device-id.patch"
SRC_URI_append += "file://0019-comment-WriteFru-from-manufacturingcommands.patch"
SRC_URI_append += "file://0020-whitlisting-ipmi-commands.patch"
SRC_URI_append += "file://0021-Whitelisting-Dcmi-commands.patch"
SRC_URI_append += "file://ipmi_sel"
SRC_URI_append += "file://0022-get-device-sdr-support.patch"
SRC_URI_append += "file://0023-Eventstatuscommand.patch"
SRC_URI_append += "file://0024-Get-Sensor-Enable-Command.patch"
SRC_URI_append += "file://0025-geteventenable-from-sdrinfo.patch"
SRC_URI_append += "file://0026-Added-messageIds-for-UI-Events.patch"
SRC_URI_append += "file://0027-getsensortype-fix.patch"
SRC_URI_append += "file://0028-Fixed-GetFruInvAreaInfo-GetSdrRepositoryInfo-GetSdrRepositoryAllocInfo-Command.patch"
SRC_URI_append += "file://0029-fixed-discreteno-reading.patch"
SRC_URI_append += "file://0030-getsdr-eventmask-from-sdrinfo.patch"
SRC_URI_append += "file://0031-eventbuf-priv.patch"
SRC_URI_append += "file://0032-remove-threshold-log-file.patch"
SRC_URI_append += "file://0033-added-sdr-device-info-dynamic-population-timestamp.patch"
#Intel patch
SRC_URI_append += "file://0034-GetFwVersionInfo-Fix-for-Firmware-aux-version.patch"
SRC_URI_append += "file://0035-firmware-update-Add-Support-to-get-fwSecurityVer.patch"
SRC_URI_append += "file://0036-Add-sufficient-delay-to-create-smbios2-file.patch"
SRC_URI_append += "file://0037-Update-Product-ID-for-EEPROM-FRU-platforms.patch"
SRC_URI_append += "file://0038-Fix-cold-redundancy-is-not-runing-as-user-configurat.patch"
SRC_URI_append += "file://0039-oemcommands-Fix-for-set-security-mode-to-mfg-mode.patch"
SRC_URI_append += "file://0040-ipmi-whitelist-Allow-set-securitymode-cmd-from-KCS.patch"
