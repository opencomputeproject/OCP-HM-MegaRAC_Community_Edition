FILESEXTRAPATHS:append := ":${THISDIR}/${PN}"

