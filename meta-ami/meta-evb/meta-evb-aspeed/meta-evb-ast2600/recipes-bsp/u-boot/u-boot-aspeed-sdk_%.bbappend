COMPATIBLE_MACHINE = "evb-ast2600"
