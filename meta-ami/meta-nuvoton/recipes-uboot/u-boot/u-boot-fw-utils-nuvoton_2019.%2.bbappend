FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://001-nuvoton-npcm750-uboot-arch.patch"
SRC_URI += "file://001-nuvoton-npcm750-olympus-uboot-arch-dts.patch"
SRC_URI += "file://001-nuvoton-npcm730-olympus-uboot-arch-dts.patch"
SRC_URI += "file://001-nuvoton-npcm750-uboot-arch-arm-mach-npcm750.patch"
SRC_URI += "file://001-nuvoton-npcm750-uboot-arch-arm-cpu-npcm750.patch"
SRC_URI += "file://002-nuvoton-npcm750-uboot-board.patch"
SRC_URI += "file://003-nuvoton-npcm750-evb-uboot-configs.patch"
SRC_URI += "file://003-nuvoton-npcm750-SVB-spinor-uboot-configs.patch"
SRC_URI += "file://003-nuvoton-npcm750-olympus-uboot-configs.patch"
SRC_URI += "file://004-nuvoton-npcm750-uboot-drivers-crypto.patch"
SRC_URI += "file://005-nuvoton-npcm750-uboot-drivers-gpio.patch"
SRC_URI += "file://006-nuvoton-npcm750-uboot-drivers-i2c.patch"
SRC_URI += "file://007-nuvoton-npcm750-uboot-drivers-misc.patch"
SRC_URI += "file://008-nuvoton-npcm750-uboot-drivers-mmc.patch"
SRC_URI += "file://009-nuvoton-npcm750-uboot-drivers-net.patch"
SRC_URI += "file://010-nuvoton-npcm750-uboot-drivers-serial.patch"
SRC_URI += "file://011-nuvoton-npcm750-uboot-drivers-spi.patch"
SRC_URI += "file://012-nuvoton-npcm750-uboot-drivers-timer.patch"
SRC_URI += "file://013-nuvoton-npcm750-uboot-drivers-usb.patch"
SRC_URI += "file://014-nuvoton-npcm750-uboot-include.patch"
SRC_URI += "file://015-nuvoton-npcm750-uboot-lib.patch"
SRC_URI += "file://016-nuvoton-npcm750-uboot-scripts.patch"
SRC_URI += "file://017-nuvoton-npcm750-uboot-Makefile.patch"
SRC_URI += "file://018-nuvoton-npcm750-uboot-README.patch"
SRC_URI += "file://019-nuvoton-npcm750-uboot-npcm7xx-readme.patch"
SRC_URI += "file://020-nuvoton-npcm750-uboot-cmd.patch"
//SRC_URI += "file://021-nuvoton-npcm750-uboot-mergetool-xml.patch"
//SRC_URI += "file://022-nuvoton-npcm750-uboot-mergetool-bingo.patch"
//SRC_URI += "file://023-nuvoton-npcm750-uboot-mergetool-bb.patch"
SRC_URI += "file://024-nuvoton-npcm750-uboot-include.patch"
SRC_URI += "file://025-nuvoton-npcm750-uboot-drivers-mtd-spi.patch"
SRC_URI += "file://026-nuvoton-npcm750-uboot-drivers-net-phy.patch"
SRC_URI += "file://027-nuvoton-npcm750-uboot-board-nuvoton.patch"
SRC_URI += "file://028-nuvoton-npcm750-olympus-uboot-tools-env.patch"
SRC_URI += "file://029-nuvoton-npcm750-uboot-drivers-pinctrl.patch"
