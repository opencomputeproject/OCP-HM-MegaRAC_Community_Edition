FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append += "file://0001-Added-Master-Kvm-Session-Support-obmc-ikvm.patch" 
#SRC_URI_append += "file://0002-Fixed-KVM-Host-Sync.patch"
