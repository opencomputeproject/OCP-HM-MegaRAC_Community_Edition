FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-RestoreDelay-interface-for-power-restore-delay.patch"
