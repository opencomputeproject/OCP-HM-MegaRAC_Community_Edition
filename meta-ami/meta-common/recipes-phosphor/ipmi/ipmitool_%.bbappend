FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "\
	       file://0001_ipmi_dcmi_get_temp_reading_offset_change.patch \
	   "








