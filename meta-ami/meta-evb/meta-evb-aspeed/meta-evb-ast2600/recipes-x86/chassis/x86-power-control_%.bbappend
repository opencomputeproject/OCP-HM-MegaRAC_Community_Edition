FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-AST2600-EVB-Power-Control.patch \
           "

