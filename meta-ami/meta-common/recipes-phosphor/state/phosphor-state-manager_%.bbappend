FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"


SRC_URI += "file://0001-Timer-Support-for-manager-reset-operation.patch" 
