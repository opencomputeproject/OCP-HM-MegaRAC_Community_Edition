FILESEXTRAPATHS_prepend := "${THISDIR}/linux-nuvoton:"

# SRC_URI += "file://evb-npcm750.cfg"
SRC_URI += "file://olympus-nuvoton-npcm750.cfg"
SRC_URI += "file://olympus-vlan.cfg"
# SRC_URI += "file://001-partitions.patch"
# SRC_URI += "file://001-arch-arm-boot-dts-nuvoton-npcm750-evb.patch"
# SRC_URI += "file://002_npcm7xx_emc-debug.patch"
SRC_URI += "file://001-arch-arm-boot-dts-nuvoton-npcm750-olympus-dts.patch"
SRC_URI += "file://002-drivers-net-ethernet-nuvoton-npcm7xx_emc.patch"
SRC_URI += "file://003-npcm750-kernel-drivers-mtd-spi-nor.patch"
SRC_URI += "file://004-arch-arm-boot-dts-nuvoton-npcm730-olympus-dts.patch"
SRC_URI += "file://005-include-dt-bindings-reset-nuvoton-npcm7xx.patch"
SRC_URI += "file://006-arch-arm-boot-dts-nuvoton-runbmc-npcm750-jtag-dts.patch"
SRC_URI += "file://007-arch-arm-boot-dts-nuvoton-runbmc-npcm750-reloc-dts.patch"
SRC_URI += "file://008-olympus-nuvoton-drivers-mtd-spi-nor.patch"
SRC_URI += "file://0003-i2c-nuvoton-npcm750-runbmc-integrate-the-slave-mqueu.patch"
SRC_URI += "file://009-olympus-nuvoton-drivers-misc-jtag-master.patch"
SRC_URI += "file://015-olympus-nuvoton-drivers-clk-npcm7xx.patch"
SRC_URI += "file://016-olympus-nuvoton-drivers-misc-vdm.patch"
SRC_URI += "file://017-olympus-nuvoton-arch-arm-boot-dts.patch"
SRC_URI += "file://018-partition-layout-changes-for-fw-flashing.patch"
SRC_URI += "file://019-olympus-nuvoton-arch-arm-boot-dts-peci.patch"
SRC_URI += "file://020-olympus-nuvoton-drivers-video.patch"
SRC_URI += "file://021-olympus-nuvoton-drivers-pinctrl.patch"
SRC_URI += "file://022-olympus-nuvoton-drivers-reset.patch"
SRC_URI += "file://023-olympus-nuvoton-drivers-hw-random.patch"
SRC_URI += "file://024-olympus-nuvoton-drivers-usb-ohci.patch"
SRC_URI += "file://025-olympus-nuvoton-drivers-hwmon-tps.patch"
SRC_URI += "file://026-olympus-nuvoton-drivers-usb-udc.patch"
SRC_URI += "file://027-olympus-nuvoton-drivers-mmc-sdhci.patch"
SRC_URI += "file://028-skip-clear-fault-for-flexpower.patch"
SRC_URI += "file://029-enable-cd-redirection-windows-iso.patch"
SRC_URI += "file://030-Fixed-KVM-Host-Sync-Issue.patch"
#SRC_URI += "file://0001-Revert-mtd-spi-nor-fix-options-for-mx66l51235f.patch"

