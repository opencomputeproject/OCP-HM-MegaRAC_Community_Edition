FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://001-openbmc-flash-layout.dtsi.patch"
