FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRCREV = "8978a5a81cddfa86423cd2a0c2a8154858df0151"

SRC_URI += " \
	   file://0004-Add-to-warm-reset.patch \
           "
