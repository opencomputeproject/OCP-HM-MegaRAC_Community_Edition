FILESEXTRAPATHS_append_mtjade := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-jade-update-restartcause-dbus-info.patch \
            "
