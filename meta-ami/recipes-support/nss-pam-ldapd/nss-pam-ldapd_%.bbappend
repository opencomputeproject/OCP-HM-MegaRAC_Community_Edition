FILESEXTRAPATHS_prepend := "${THISDIR}:"

SRC_URI += "file://Enable_Burst_Time.patch;patchdir=${WORKDIR}"
