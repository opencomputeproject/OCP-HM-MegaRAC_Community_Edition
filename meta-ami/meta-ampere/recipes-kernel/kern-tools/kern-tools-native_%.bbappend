# kernel 5.14 requires updated kerntools
SRCREV = "d220b063852245fdd16b9731a395ace525f932d6"
