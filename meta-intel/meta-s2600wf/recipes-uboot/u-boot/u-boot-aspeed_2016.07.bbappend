FILESEXTRAPATHS_append := "${THISDIR}/:"

SRC_URI_append_aspeed += "file://ast-common.patch"
