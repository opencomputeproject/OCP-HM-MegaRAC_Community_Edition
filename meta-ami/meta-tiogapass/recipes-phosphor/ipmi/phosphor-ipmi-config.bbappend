FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append += "file://dcmi_sensors.json"
SRC_URI_append += "file://dcmi_cap.json"

