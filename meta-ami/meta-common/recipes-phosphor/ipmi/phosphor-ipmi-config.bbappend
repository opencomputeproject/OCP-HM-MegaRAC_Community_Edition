FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += " \
	   file://dcmi_cap.json \
	   file://dev_id.json \
           "

