FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
            file://dropbear.default \
         "

