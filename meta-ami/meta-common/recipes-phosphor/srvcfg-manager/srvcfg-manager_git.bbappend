FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI:append = " file://0001-Added-Virtualmedia-service-to-service-Config-Manager.patch"

