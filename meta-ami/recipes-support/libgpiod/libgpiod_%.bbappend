FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI +=  "file://0001-gpioget-readback-gpioset-value.patch;patchdir=${WORKDIR}"
