FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	     file://0001-Add-Enable-After-Reset-support-in-biosconfig.patch \
           "
