FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://wolfpass.cfg"
SRC_URI += "file://wolfpass.dts.patch"
