FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://channel_config.json "
           
