FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append += "file://0001-Fixed-master-write-read-command.patch"
SRC_URI_append += "file://0002-Renamed-SEL-sensor.patch"
