FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


SRC_URI_append = " file://0001-Renamed-Watchdog2-Sensor.patch"

