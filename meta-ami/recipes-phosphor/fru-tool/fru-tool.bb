SUMMARY = "Fru Tool"

DESCRIPTION = "Fru-tool to generate fru.bin"


SRC_URI = "file://fru-tool"
LICENSE = "CLOSED"

S = "${WORKDIR}"

do_compile(){
}
